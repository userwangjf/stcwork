# Keil uVision project stc.uvproj, settings and files
target stc (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: stc +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: KEILC51
  c include: ..
  link misc: REMOVEUNUSED
  group startup
    ../startup/: STARTUP.A51
  group bsp
    ../bsp/: delay.c Exti.c GPIO.c timer.c USART.C PCA.c random.c crc.c EEPROM.c
  group app
    ../app/: main.c task.c led_disp.c key_scan.c
  group shell
    ../shell/: shell.c printk.c str.c
  group w25qxx
    ../w25qxx/: w25qxx.c
  group tetris
    ../tetris/: tetris.c tetris_init.c
  group snake
    ../snake/: snake.c
  group driver
    ../xmodem/: xmodem.c xmodem_init.c
  group music
    ../music/: music.c
  group save
    ../save/: save.c save_init.c
  group romfs
    ../romfs/: romfs.c romfs_init.c fifo.c
