# Keil uVision project stc.uvproj, settings and files
target stc (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: stc +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..
  link misc: REMOVEUNUSED
  group boot
    ./: STARTUP.A51
  group bsp
    ../bsp/: delay.c Exti.c GPIO.c timer.c USART.C PCA.c random.c crc.c printk.c
  group app
    ../app/: main.c task.c seg_disp.c
  group ds3231
    ../ds3231/: ds3231.c
  group os
    ../os/: os_sch.c os_test.c
